# IAR project VirtualComport_Loopback.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM3210B-EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkOutputFile: VirtualComport_Loopback.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xG ST STM32F103xG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_XL_VirtualComport_Loopback.bin
configuration STM32L152-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
configuration STM32L152D-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152D-EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
configuration STM32373C_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F373xC ST STM32F373xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F37X; USE_STM32373C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32373C_EVAL
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkIcfFile: stm32f37x_flash.icf
configuration STM32303C_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32303C_EVAL
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
configuration STM32F303C TEST (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL; _TEST_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_VirtualComport_Loopback.bin
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  group (top)
    ../: .gitignore
  group Doc
    ../: readme.txt
  group STM32F10x/CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
    ../src/: system_stm32f10x.c
  group STM32F10x/STM3210B_EVAL
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group STM32F10x/STM3210C_EVAL
    ../../../Utilities/STM32_EVAL/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_ioe.c
  group STM32F10x/STM3210E_EVAL
    ../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group STM32F30X/CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
    ../src/: system_stm32f30x.c
  group STM32F30X/STM32303C_EVAL
    ../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group STM32F30X/STM32F30x_StdPeriph_Driver
    ../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_syscfg.c
  group STM32F37X/CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/iar/: startup_stm32f37x.s
    ../src/: system_stm32f37x.c
  group STM32F37X/STM32373C_EVAL
    ../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c stm32373c_eval_lcd.c
  group STM32F37X/STM32F37x_StdPeriph_Driver
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_rcc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_usart.c
  group STM32L1xx/CMSIS
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
    ../src/: system_stm32l1xx.c
  group STM32L1xx/STM32L152_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group STM32L1xx/STM32L152D_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group STM32L1xx/STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: controller.c controller.h host_io.c host_io.h hw_config.c kinematics.cpp kinematics.h main.c mx_gpio.c parser.c parser.h queue.cpp queue.h stm32_it.c test.cpp test.h uart.cpp uart.h usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c wireless.cpp wireless.h zero.c
    ../inc/: mx_gpio.h
